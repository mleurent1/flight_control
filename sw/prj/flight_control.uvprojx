# Keil uVision project flight_control.uvprojx, settings and files
target Motolab (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flight_control +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F3
  c include: ..\inc;..\cmsis\inc;..\usb_vcp\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: flight_control.sct
  group FC
    ../src/: fc_revolution.c fc_reg.c fc_motolab.c
  group CMSIS
    ../cmsis/src/: system_stm32f3xx.c system_stm32f4xx.c
    ../cmsis/: startup_stm32f303xc.s startup_stm32f405xx.s
  group USB_VCP
    ../usb_vcp/src/: stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c usbd_cdc.c usbd_cdc_if.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
target Revolution (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flight_control +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4
  c include: ..\inc;..\cmsis\inc;..\usb_vcp\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: flight_control.sct
